PACKAGECONFIG_append = " dbus"
PACKAGECONFIG_remove = "x11 xcb xkb xkbcommon-evdev"
